# Keil uVision project Thermostat.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55WD Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x4FFF) CLOCK(33000000) MODP2
  output: Thermostat +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Inc/: LCD.h Menu.h Util.h
    ./Src/: LCD.c Menu.c Util.c
    ./: main.c
